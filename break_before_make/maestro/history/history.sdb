<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Oct 27 01:14:54 2024</timestamp>
			<uuid>{e26de350-c44d-4687-a3ce-e38ceb44dce9}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/dgk64/SKY130_PDK/FA24SP25Analog/break_before_make/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/dgk64/SKY130_PDK/FA24SP25Analog/break_before_make/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/dgk64/simulation/results/maestro/ExplorerRun.0</psfdir>
			<simdir>/home/dgk64/simulation/results/maestro/ExplorerRun.0</simdir>
		</historyentry>
	</history>
</setupdb>
